# Keil uVision project ElevatorSimulator.uvprojx, settings and files
target TM4C123GH6PM (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ElevatorSimulator +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ../TivaWare_C_Series-2.2.0.295;Processes;Processes/elevator-mgr/include;Processes\elevator-rx-drv\include;Processes\elevator-tx-drv\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c
    ./Processes/elevator-rx-drv/src/: elevator-rx-drv.c
    ./Processes/elevator-tx-drv/src/: elevator-tx-drv.c
    ./Processes/elevator-mgr/src/: elevator-mgr.c
  group Documentation
    ./Documents/: readme.txt
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
  group utils
    ./: uartstdio.c
  group Include
    ./Processes/: defs.h
    ./Processes/elevator-tx-drv/include/: elevator-tx-drv.h
    ./Processes/elevator-rx-drv/include/: elevator-rx-drv.h
    ./Processes/elevator-mgr/include/: elevator-mgr.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Message Buffer 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.0.1
